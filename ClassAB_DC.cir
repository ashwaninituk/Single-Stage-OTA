Class AB Amplifier Circuit.

*******************************************************
* DC Analysis of Class AB Amplifier                   *
* Assignment : Course Project                         *
* Deadline:15/Apr/2021 E.O.D.                         *
* Author: Ashwani Kumar Sharma                        *
* Roll No.: 204102402                                 *
*******************************************************

.include 45nm_LP.pm

*Circuit Netlist and Supplies.
Vdd sup 0 dc 1.1V
Vin in 0 dc 1.1V
Vcn g910c 0 dc 0.72V
Vcp g78c 0 dc 0.42V
M1 d1 in s1 s1 pmos W=21.6u L=270n
M2 d2 in s2 s2 pmos W=21.6u L=270n
M7 d7 g78 sup sup pmos W=21.6u L=270n
M8 d81 g78 sup sup pmos W=21.6u L=270n
M7c g78 g78c d7 d7 pmos W=21.6u L=270n
M8c out1 g78c d8 d8 pmos W=21.6u L=270n
M9c g78 g910c d1 d1 nmos W=5.4u L=270n
M10c out g910c d2 d2 nmos W=5.4u L=270n
M9 d1 g9 0 0 nmos W=10.8u L=270n
M10 d2 g10 0 0 nmos W=10.8u L=270n
Cbat1 g5 g10 0.7pf
Cbat2 g6 g9 0.7pf
CL out 0 70pF
Vdum out1 out dc 0V
Vdm5 d81 d8 dc 0V

*Adaptive Biasing Circuit for folding MOS
Ibias1 sup g11 10u
M11c g11 g910c s11 s11 nmos W=5.4u L=270n
M11 s11 g11 0 0 nmos W=5.4u L=270n
Mr1 g10 g11 g11 g11 pmos W=2u L=270n
Mr2 g9 g11 g11 g11 pmos W=2u L=270n

*Adaptive Biasing Circuit for input MOS
Ibias2 g5 0 10u
Ibias3 g6 0 10u
M5 s21 g5 sup sup pmos W=3u L=270u
M6 s11 g6 sup sup pmos W=3u L=270u
M3 g51 in s2 s2 pmos W=21.6u L=270u
M4 g61 in s1 s1 pmos W=21.6u L=270u

*Control block starts here.
.control
  run
  dc Vin 0V 1.1V 0.1V
  plot V(out)
  plot deriv(V(out))
  plot -Vdd#branch
  plot Vdum#branch
  let curr = -Vdd#branch
  let out_curr = Vdum#branch
  let power = 1.1*curr
  meas dc Bias_Current find curr at = 0.3V
  meas dc Out_Current find out_curr at = 0.3V
  meas dc Static_Power find power at = 0.3V
.endc
*Control block ends here.
.end
